# Keil uVision project LJB_205RC.uvproj, settings and files
target STM32F205RC (ARM-ADS)
  device: STM32F205RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LYF1305LJA_A +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER   DEBUG   LJB_CPU_MAIN  USE_CPU_F205RC
  c include: ..\BSP;..\BSP\UCOS-II;..\BSP\STM32F2xx\inc;..\BSP\CMSIS;..\BSP\CMSIS\Device_Support;..\BSP\UCOS-II;..\..\uC-CPU;..\..\uC-CPU\ARM-Cortex-M3;..\..\uC-LIB;..\..\uC-LIB\Ports\ARM-Cortex-M3;..\..\uCOS-II\Source;..\..\uCOS-II\Ports\ARM-Cortex-M3;..\App;..\Prj
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ../App/: app_hooks.c app.c SineTable.c MiscFnx.c Usart_Common.c F205_Flash.c app_led.c app_HPI.c app_adc.c app_i2c1.c app_usart1.c app_usart6.c
  group BSP
    ../BSP/KeilMDK/: cstartup.s
    ../BSP/: bsp.c bsp_int.c bsp_ser.c bsp_ADC.c bsp_DAC.c bsp_fsmc_sram.c bsp_can.c bsp_i2c.c bsp_spi_flash.c bsp_gpio.c bsp_led.c bsp_rtc.c bsp_sd.c bsp_sdio.c bsp_tm3.c bsp_tm6.c bsp_usart.c
    ../BSP/UCOS-II/: bsp_os.c
    ../BSP/CMSIS/Device_Support/: system_stm32f2xx.c
  group UC/CPU
    ../../uC-CPU/: cpu_core.c
    ../../uC-CPU/ARM-Cortex-M3/: cpu_c.c cpu_a.asm
  group UC/LIB
    ../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../uC-LIB/Ports/ARM-Cortex-M3/: lib_mem_a.asm
  group UC/OS-II Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UC/OS-II Port
    ../../uCOS-II/Ports/ARM-Cortex-M3/: os_dbg.c os_cpu_c.c os_cpu_a.asm
  group STM32F2xx Library
    ../BSP/STM32F2xx/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
