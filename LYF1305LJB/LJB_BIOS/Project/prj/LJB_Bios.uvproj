# Keil uVision project LJB_Bios.uvproj, settings and files
target BIOS (ARM-ADS)
  device: STM32F205RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LYF1305LJA_B +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER   USE_CPU_F205RC   LJB_CPU
  c include: ..\src;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\STM32F2xx;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Utilities\STM32_EVAL;..\src\SYSTICK;..\src\LED;..\src\GPIO;..\src\USART;..\src\FLASH;..\src\HexFile
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../../Libraries/CMSIS/CM3/DeviceSupport/STM32F2xx/: system_stm32f2xx.c
    ../src/: stm32f2xx_it.c main.c
    ../src/HexFile/: HexFile.c
    ../src/FLASH/: F205_Flash.c
    ../src/GPIO/: F205_Gpio.c
    ../src/LED/: F205_Led.c
    ../src/SYSTICK/: F205_systick.c
    ../src/USART/: F205_usart.c
  group DeviceDriver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_usart.c stm32f2xx_exti.c stm32f2xx_syscfg.c
  group cmsis
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group start_up
    ../: startup_stm32f2xx.s
  group eval
    ../../Utilities/STM32_EVAL/: stm322xg_eval.c
